# Keil uVision project temp10ch.uvproj, settings and files
target temp10ch (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: temp10ch-11B +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\SYSTEM;.\HARDWARE
  group USER
    ./USER/: main.c
  group HARDWARE
    ./HARDWARE/: timer.c uart.c flashrom.c i2c.c sht30.c ds18b20.c
  group SYSTEM
    ./SYSTEM/: receservice.c config.c wdt.c
